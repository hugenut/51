# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: TS80C52X2 Microchip
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(60000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
